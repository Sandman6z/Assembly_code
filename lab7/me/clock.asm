		ORG 0000H
		AJMP MAIN
		ORG 000BH
		AJMP ITOP
MAIN:	MOV TMOD,#01H
		MOV 20H,#0AH
		CLR A
		MOV 40H,A
		MOV 41H,A
		MOV 42H,A
		SETB ET0
		SETB EA
		MOV TH0,#3CH
		MOV TL0,#0B0H
		SETB TR0
		SJMP $
ITOP:	PUSH PSW
		PUSH ACC
		MOV TH0,#3CH
		MOV TL0,#0B0H
		DJNZ 20H,RETURN
		MOV 20H,#0AH
		MOV A,#01H
		ADD A,42H
		DA A
		MOV 42H,A
		CJNE A,#60H,RETURN
		MOV 42H,#00H
		MOV A,#01H
		ADD A,41H
		DA A
		MOV 41H,A
		CJNE A,#60,RETURN
		MOV 41H,#00H
		MOV A,#01H
		ADD A,40H
		DA A
		MOV 40H,A
		CJNE A,#24,RETURN
		MOV 40H,#00H
RETURN:	POP ACC
		POP PSW
		RETI
		END