		ORG 0000H
		LJMP MAIN
		ORG 0100H
MAIN:   MOV SCON,#50H
		MOV PCON,#00H	/* SMOD=0 */
		MOV TMOD,#20H
		MOV TH1,#0F3H
		MOV TL1,#0F3H
		SETB TR1
LOOP:	MOV R0,#30H	   ;RAM
		MOV R6,#8 	   ;bit

COM:	JBC RI,SEND1
		SJMP COM

SEND1:	MOV A,SBUF
		MOV @R0,A
		INC R0
		DJNZ R6,COM
		MOV SBUF,#55H

WAIT1:  JBC TI,SEND2
		SJMP WAIT1

SEND2:	MOV SBUF,#0AAH

RECE:   JNB TI,RECE
		CLR TI
		
		SJMP LOOP
END